# IAR project Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: config.h main.c startup_ewarm.c tm4c123gh6pm.h
  group Drivers
    Drivers/: buzzer.c buzzer.h eeprom.c eeprom.h motor.c motor.h timer.c timer.h uart.c uart.h
  group inc
    inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h sc4c1290kcpdt.h sc4c1294ncpdt.h sc4ca294ncpdt.h sc4cb297nczad.h sc4cc231e6pm.h sc4ce290ncpz.h sc4ce93xh6pm.h tm4c1230c3pm.h tm4c1230d5pm.h tm4c1230e6pm.h tm4c1230h6pm.h tm4c1231c3pm.h tm4c1231d5pm.h tm4c1231d5pz.h tm4c1231e6pm.h tm4c1231e6pz.h tm4c1231h6pge.h tm4c1231h6pm.h tm4c1231h6pz.h tm4c1232c3pm.h tm4c1232d5pm.h tm4c1232e6pm.h tm4c1232h6pm.h tm4c1233c3pm.h tm4c1233d5pm.h tm4c1233d5pz.h tm4c1233e6pm.h tm4c1233e6pz.h tm4c1233h6pge.h tm4c1233h6pm.h tm4c1233h6pz.h tm4c1236d5pm.h tm4c1236e6pm.h tm4c1236h6pm.h tm4c1237d5pm.h tm4c1237d5pz.h tm4c1237e6pm.h tm4c1237e6pz.h tm4c1237h6pge.h tm4c1237h6pm.h tm4c1237h6pz.h tm4c123ae6pm.h tm4c123ah6pm.h tm4c123be6pm.h tm4c123be6pz.h tm4c123bh6pge.h tm4c123bh6pm.h tm4c123bh6pz.h tm4c123bh6zrb.h tm4c123fe6pm.h tm4c123fh6pm.h tm4c123ge6pm.h tm4c123ge6pz.h tm4c123gh6pge.h tm4c123gh6pm.h tm4c123gh6pz.h tm4c123gh6zrb.h tm4c123gh6zxr.h tm4c1290ncpdt.h tm4c1290nczad.h tm4c1292ncpdt.h tm4c1292nczad.h tm4c1294kcpdt.h tm4c1294ncpdt.h tm4c1294nczad.h tm4c1297nczad.h tm4c1299kczad.h tm4c1299nczad.h tm4c129cncpdt.h tm4c129cnczad.h tm4c129dncpdt.h tm4c129dnczad.h tm4c129ekcpdt.h tm4c129encpdt.h tm4c129enczad.h tm4c129lnczad.h tm4c129xkczad.h tm4c129xnczad.h
  group Logic
    logic/: buffer.c buffer.h passowrd.c password.h statemachine.c statemachine.h
  group Tests
    Tests/: test_buzzer.c test_eeprom.c test_functions.c test_functions.h test_motor.c test_statemachine.c test_timer.c test_uart.c
